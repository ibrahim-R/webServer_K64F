# Keil uVision project HTTP_SD_Server_K64F.uvprojx, settings and files
target HTTP_SD_Server_K64F (ARM-ADS)
  device: LPC812M101JDH20 NXP
  pack: Keil.LPC800_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: HTTP_SD_Server_K64F
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: __MICROLIB DEVICE_SLEEP=1 MBED_RTOS_SINGLE_THREAD __CORTEX_M0PLUS __ASSERT_MSG MBED_BUILD_TIMESTAMP=1540332459.09 DEVICE_PWMOUT=1 TARGET_FF_ARDUINO TARGET_M0P DEVICE_SPISLAVE=1 TARGET_RELEASE DEVICE_SERIAL_FC=1 TARGET_LIKE_CORTEX_M0 TOOLCHAIN_ARM_MICRO TARGET_LPC812 TARGET_CORTEX_M ARM_MATH_CM0PLUS DEVICE_I2C=1 TOOLCHAIN_ARM DEVICE_I2CSLAVE=1 TARGET_LPC81X TARGET_LPCTarget TARGET_LIKE_MBED DEVICE_SPI=1 __MBED__=1 DEVICE_SERIAL=1 TARGET_CORTEX DEVICE_INTERRUPTIN=1 __CMSIS_RTOS TARGET_NXP __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --library_type=microlib --cpu=Cortex-M0 --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: .;mbed;mbed/TARGET_LPC812;mbed/TARGET_LPC812/TARGET_NXP/TARGET_LPC81X;mbed/TARGET_LPC812/TARGET_NXP/TARGET_LPC81X/TARGET_LPC812
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-DARM_MATH_CM0PLUS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: /filer/web_data/repo_builds/4/243/TARGET_LPC812/TOOLCHAIN_ARM_MICRO/LPC812.sct
  link misc: --library_type=microlib --show_full_path
  group HTTP_SD_Server_K64F
    ./: main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_LPC812/TOOLCHAIN_ARM_MICRO/: board.o cmsis_nvic.o mbed.ar retarget.o startup_LPC8xx.o sys.o system_LPC8xx.o
    mbed/TARGET_LPC812/: cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h LPC8xx.h system_LPC8xx.h
    mbed/TARGET_LPC812/TARGET_NXP/TARGET_LPC81X/: device.h gpio_object.h objects.h PortNames.h
    mbed/TARGET_LPC812/TARGET_NXP/TARGET_LPC81X/TARGET_LPC812/: PeripheralNames.h PinNames.h
